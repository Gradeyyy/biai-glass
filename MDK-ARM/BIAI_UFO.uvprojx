# Keil uVision project BIAI_UFO.uvprojx, settings and files
target BIAI_UFO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BIAI_UFO_APP +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G491xx
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\APP_Inc;..\Bsp_Src;..\User;..\Drivers\CMSIS\Core\Include;..\VL53L0X\core\inc;..\VL53L0X\demo;..\VL53L0X\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../APP_Src/: adc.c algorithm.c gpio.c ICM_20608.c tim.c usart.c work_drive.c key_scan.c OPT3001.c wwdg.c i2c.c flash_rw.c vl53l0x.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_i2c.c vl53l0x_platform.c ZD25WQ32C.c td5322a.c stm32_ota.c
  group Application/User
    ../User/: main.c stm32g4xx_it.c startup_stm32g491xx.s
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_gpio.c stm32g4xx_hal_tim.c stm32g4xx_hal.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_rtc.c stm32g4xx_hal_smbus.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_qspi.c
  group Drivers/CMSIS
    ../User/: system_stm32g4xx.c
  group Application/VL53L0X
    ../VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
software components: CMSIS:CORE 5.5.0
